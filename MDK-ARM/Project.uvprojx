# Keil uVision project Project.uvprojx, settings and files
target PY32F002Bx5_Project (6160000::V6.16::ARMCLANG)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,PY32F002Bx5
  c include: C:\env\embedded_cxx\custom;..\Core\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\PY32F002B_HAL_Driver\Inc;..\Components;..\Components\custom;..\Components\RTT;..\Applications\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Application/MDK-ARM
    ./: startup_py32f002bxx.s
  group Application/User/Core
    ../Core/Src/: main.c py32f002b_hal_msp.c py32f002b_it.c
  group Drivers/PY32F002B_HAL_Driver
    ../Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_adc.c py32f002b_hal_comp.c py32f002b_hal_cortex.c py32f002b_hal_crc.c py32f002b_hal_exti.c py32f002b_hal_flash.c py32f002b_hal_gpio.c py32f002b_hal_i2c.c py32f002b_hal_iwdg.c py32f002b_hal_lptim.c py32f002b_hal_pwr.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_spi.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_uart.c py32f002b_hal_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_py32f002b.c
  group Components/RTT
    C:/env/embedded_cxx/custom/log/segger/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Applications
    ../Applications/Src/: board.cpp application.cpp button.cpp remote_decoder.cpp ticker.cpp display.cpp gpio.cpp beep.cpp memory.cpp
software components: CMSIS:CORE 5.4.0
